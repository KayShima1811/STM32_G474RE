# Keil uVision project Learning_STM32_G474RE.uvprojx, settings and files
target STM32_G474RE (6190000::V6.19::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Learning_STM32_G474RE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup File
    ./: startup_stm32g474xx.s system_stm32g4xx.c
  group Core
    ./: main.c Define_G4.h Init_Config_G4.c Function.c Handler_EXTI_G4.c
software components: CMSIS:CORE 5.6.0
